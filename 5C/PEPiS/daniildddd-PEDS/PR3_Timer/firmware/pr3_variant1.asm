; ПР №3, Вариант 1: P1.3, S=2с ON / K=1с OFF, T=3мин (60 циклов)
; МК-51, Fosc=12МГц -> Tмаш=1мкс. T/C0, режим 1 (16 бит), база 50мс.
; Перезагрузка: 65536-50000=15536=3CB0h -> TH0=3Ch, TL0=0B0h.
; S=40x50мс, K=20x50мс. Опрос флага TF0 (программный режим, без прерываний).
; P1.3 управляется битовыми командами, остальные биты P1 не трогаем.
; Сборка: Keil / SDCC (sdas8051). Частота кварца BQ1=12МГц (см. схему).

$MOD51              ; подключение определений МК-51 (Keil). Для sdas8051 заменить на include.

        ORG 0000h
        LJMP START  ; вектор сброса

        ORG 0030h
START:  CLR C
        MOV TMOD, #01h   ; T/C0: таймер, режим 1 (M1M0=01, C/T=0, GATE=0)
        MOV P1, #00h     ; все линии P1 в 0 (LED погашен), P1.3=0
        MOV R7, #3Ch     ; R7, счётчик циклов T: 60 = 3Ch (180с / 3с)
CYCLE:  ; ---- фаза ON: P1.3=1, держать S=2с ----
        SETB P1.3        ; зажечь HL1 (P1.3=1 -> R1 270 Ом -> HL1 -> GND)
        MOV R0, #28h     ; R0=40 (28h), счётчик базы 50мс для S=2с
ON_LOOP:MOV TH0, #3Ch    ; старший байт перезагрузки (50мс)
        MOV TL0, #0B0h   ; младший байт перезагрузки (50мс)
        SETB TCON.4      ; TR0=1, пуск T/C0
WAIT_ON: JNB TCON.5, WAIT_ON ; ждать TF0=1 (переполнение через 50мс)
        CLR TCON.5       ; сбросить TF0 программно (в режиме опроса сам не сбрасывается)
        CLR TCON.4       ; TR0=0, остановить таймер перед перезагрузкой
        DJNZ R0, ON_LOOP ; повторить 40 раз -> 2000мс
        ; ---- фаза OFF: P1.3=0, держать K=1с ----
        CLR P1.3         ; погасить HL1
        MOV R0, #14h     ; R0=20 (14h), счётчик базы 50мс для K=1с
OFF_LOOP:MOV TH0, #3Ch
        MOV TL0, #0B0h
        SETB TCON.4
WAIT_OFF:JNB TCON.5, WAIT_OFF
        CLR TCON.5
        CLR TCON.4
        DJNZ R0, OFF_LOOP ; повторить 20 раз -> 1000мс
        DJNZ R7, CYCLE   ; следующий цикл вкл/выкл (всего 60 -> 3 мин)
        ; ---- конец T: оставить LED погашенным и остановиться ----
        CLR P1.3
        SJMP $           ; бесконечный останов (while(1))
        END
