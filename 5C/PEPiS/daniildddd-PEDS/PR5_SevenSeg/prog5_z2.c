/* ПР №5, Задание 2 (вариант 1): a=23, b=52 (BCD) -> сумма на двухразрядный
 * индикатор, порт P1. Схема: PR5_SevenSeg.kicad_sch, блок DD2 (справа).
 * Способ программный + динамическая индикация: сегменты 2A-2H на P1 через
 * R13-R20 270 Ом; разряды HG4 (десятки) и HG5 (единицы) выбираются ключами
 * VT4/VT5 с линий P3.0/P3.1 (0 = разряд включён).
 *
 * Расчёт BCD-сложения:
 *   a = 0x23 (BCD 23), b = 0x52 (BCD 52)
 *   0x23 + 0x52 = 0x75; младшая тетрада 3+2=5 (<=9), старшая 2+5=7 (<=9),
 *   переносов из тетрад нет, поэтому команда DAA поправок не вносит
 *   и результат остаётся 0x75 = BCD 75.
 *   Десятки = 7 -> код 0xF8; единицы = 5 -> код 0x92.
 * Если бы тетрада превысила 9 или дала перенос, DAA прибавила бы 6
 * к этой тетраде (стандартная десятичная коррекция МК-51).
 */
#include <8051.h>

void delay(void)               /* задержка свечения одного разряда */
{
    unsigned int k;
    for (k = 0; k < 1500; k++)
        continue;
}

void main(void)
{
    unsigned char code seg[10] =
        {0xC0, 0xF9, 0xA4, 0xB0, 0x99, 0x92, 0x82, 0xF8, 0x80, 0x90};
    unsigned char a = 0x23;    /* вариант 1: BCD 23 */
    unsigned char b = 0x52;    /* вариант 1: BCD 52 */
    unsigned char sum;         /* BCD-сумма = 0x75 */
    unsigned char digits[2];   /* цифры HG4 (десятки), HG5 (единицы) */
    unsigned char code SEL[2] = {0xFE, 0xFD};  /* выбор VT4 (P3.0), VT5 (P3.1) */
    unsigned char i;

    /* --- BCD-сложение средствами МК-51: ADD + десятичная коррекция DAA --- */
    /* В C для 8051 (SDCC) десятичная коррекция после сложения BCD выполняется
       тем же правилом, что команда DA A в ассемблере: если младшая тетрада > 9
       или было вспомогательное перенос, прибавить 6 к младшей тетраде;
       то же для старшей тетрады с флагом переноса. Здесь:
       3+2=5 (норма), 2+5=7 (норма) -> поправок нет, sum = 0x75. */
    sum = a + b;               /* 0x23 + 0x52 = 0x75 */
    /* программный эквивалент DA A (для данного варианта поправок нет): */
    if ((sum & 0x0F) > 9)      /* младшая тетрада > 9? (здесь 5 -> нет) */
        sum += 0x06;
    if ((sum & 0xF0) > 0x90)   /* старшая тетрада > 9? (здесь 7 -> нет) */
        sum += 0x60;           /* итог: sum = 0x75 = BCD 75 */

    digits[0] = (sum >> 4) & 0x0F;  /* HG4 покажет 7 */
    digits[1] = sum & 0x0F;         /* HG5 покажет 5 */

    P1 = 0xFF;                 /* погасить сегменты */
    P3 |= 0x03;                /* закрыть оба ключа */
    while (1)
    {
        for (i = 0; i < 2; i++)    /* цикл динамической индикации */
        {
            P3 |= 0x03;            /* закрыть все ключи (защита от ghosting) */
            P1 = seg[digits[i]];   /* код цифры на шину 2A-2H */
            P3 &= SEL[i];          /* открыть ключ i-го разряда */
            delay();
        }
    }
}
