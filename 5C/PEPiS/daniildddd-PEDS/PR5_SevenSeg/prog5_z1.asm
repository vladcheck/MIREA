; ПР №5, Задание 1 (вариант 1): VAL=0FFh -> трёхразрядный индикатор, порт P1.
; МК-51, ассемблер. Программный вариант (рисунки 44/46 ТЗ) + динамическая индикация.
; Схема: PR5_SevenSeg.kicad_sch, блок DD1. Сегменты 1A-1H на P1 через R1-R8
; 270 Ом; выбор разряда HG1-HG3 ключами VT1-VT3 с P3.0-P3.2 (0 = разряд вкл).
;
; Расчёт: VAL=0FFh=255 -> сотни 2, десятки 5, единицы 5.
; Преобразование байт->BCD — цепочкой DIV из ТЗ (сначала /100, потом /10):
;   A=255: B=100, DIV -> A=2 (сотни), B=55 (остаток)
;   A=55:  B=10,  DIV -> A=5 (десятки), B=5 (единицы)
$MOD51                 ; подключение МК-51
          ORG 20h      ; начинаем программу с адреса 20h

          MOV A,#0FFh  ; VAL = 0FFh (вариант 1)
          MOV B,#100   ; делитель 100 для вычисления сотен
          DIV AB       ; A = 2 (сотни), B = 55 (остаток)
          MOV R0,A     ; R0 = сотни (HG1 покажет 2)
          XCH A,B      ; A = остаток 55
          MOV B,#10    ; делитель 10 для десятков
          DIV AB       ; A = 5 (десятки), B = 5 (единицы)
          MOV R1,A     ; R1 = десятки (HG2 покажет 5)
          MOV R2,B     ; R2 = единицы (HG3 покажет 5)

SCAN:     MOV R4,#3    ; счётчик разрядов
          MOV R5,#0FEh ; маска P3: первым открываем VT1 (P3.0=0)
          MOV DPTR,#ZG ; начало таблицы знакогенератора
DIGIT:    MOV A,R4     ; выбрать цифру разряда: 3->R0, 2->R1, 1->R2
          CJNE A,#3,NOTH
          MOV A,R0
          SJMP OUT
NOTH:     CJNE A,#2,NOTT
          MOV A,R1
          SJMP OUT
NOTT:     MOV A,R2
OUT:      MOVC A,@A+DPTR ; код цифры из таблицы (общий анод)
          ORL P3,#07h  ; закрыть все ключи (защита от ghosting)
          MOV P1,A     ; выставить код на шину 1A-1H
          MOV A,R5     ; маска выбора разряда
          ANL P3,A     ; открыть ключ текущего разряда
          ACALL PAUSE  ; задержка свечения разряда
          MOV A,R5     ; сдвинуть ноль маски на следующий разряд
          RL A
          MOV R5,A
          DJNZ R4,DIGIT
          SJMP SCAN    ; бесконечный цикл динамической индикации

PAUSE:    MOV R3,#255  ; задержка для устойчивого свечения разряда
P1:       NOP
          NOP
          DJNZ R3,P1
          RET

          ORG 0100h    ; таблица кодов с адреса 100h
ZG:                    ; знакогенератор (общий анод, из ТЗ)
          DB 11000000b ; символ «0» = 0C0h
          DB 11111001b ; символ «1» = 0F9h
          DB 10100100b ; символ «2» = 0A4h
          DB 10110000b ; символ «3» = 0B0h
          DB 10011001b ; символ «4» = 099h
          DB 10010010b ; символ «5» = 092h
          DB 10000010b ; символ «6» = 082h
          DB 11111000b ; символ «7» = 0F8h
          DB 10000000b ; символ «8» = 080h
          DB 10010000b ; символ «9» = 090h
          END
