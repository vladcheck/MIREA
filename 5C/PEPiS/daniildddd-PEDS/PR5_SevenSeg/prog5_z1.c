/* ПР №5, Задание 1 (вариант 1): VAL=0FFh вывести на трёхразрядный индикатор, порт P1.
 * Схема: PR5_SevenSeg.kicad_sch, блок DD1 (слева).
 * Способ программный (рисунки 44/46 ТЗ): 8 линий P1 через R=270 Ом на общую
 * сегментную шину 1A-1H; разряды HG1-HG3 (сотни/десятки/единицы) выбираются
 * ключами VT1-VT3 с линий P3.0-P3.2 (динамическая индикация).
 *
 * Расчёт для VAL = 0FFh = 255:
 *   сотни  = 255 / 100 = 2        -> код 0xA4
 *   остаток = 255 - 200 = 55
 *   десятки = 55 / 10 = 5         -> код 0x92
 *   единицы = 55 - 50 = 5         -> код 0x92
 * Таблица кодов для общего анода (из ТЗ, бит=0 зажигает сегмент):
 *   0:C0 1:F9 2:A4 3:B0 4:99 5:92 6:82 7:F8 8:80 9:90
 * Ключи VT1-VT3 (p-n-p) открываются НУЛЁМ на линии P3: активный разряд = 0,
 * неактивные = 1. Поэтому маска выбора разряда инверсная (см. SEL[]).
 */
#include <8051.h>

void delay(void)               /* задержка свечения одного разряда (~2 мс при 12 МГц) */
{
    unsigned int k;
    for (k = 0; k < 1500; k++)
        continue;
}

void main(void)
{
    /* коды цифр 0-9 для индикатора с общим анодом (таблица из ТЗ) */
    unsigned char code seg[10] =
        {0xC0, 0xF9, 0xA4, 0xB0, 0x99, 0x92, 0x82, 0xF8, 0x80, 0x90};
    unsigned char VAL = 0xFF;  /* вариант 1: 0FFh = 255 */
    unsigned char h, t, o;     /* сотни, десятки, единицы */
    unsigned char digits[3];   /* цифры по разрядам HG1..HG3 */
    /* инверсные маски выбора разряда: 0 на линии P3.x открывает ключ VTx */
    unsigned char code SEL[3] = {0xFE, 0xFD, 0xFB};  /* P3.0, P3.1, P3.2 */
    unsigned char i;

    /* --- преобразование байта в цифры (то же, что DIV-цепочка из ТЗ) --- */
    h = VAL / 100;             /* 255/100 = 2 (сотни) */
    t = (VAL % 100) / 10;      /* 55/10 = 5 (десятки) */
    o = VAL % 10;              /* 5 (единицы) */
    digits[0] = h;             /* HG1 покажет 2 */
    digits[1] = t;             /* HG2 покажет 5 */
    digits[2] = o;             /* HG3 покажет 5 */

    P1 = 0xFF;                 /* погасить сегменты (общий анод: 1 = сегмент выкл) */
    P3 |= 0x07;                /* закрыть все ключи разрядов */
    while (1)
    {
        for (i = 0; i < 3; i++)    /* цикл динамической индикации */
        {
            P3 |= 0x07;            /* сначала закрыть все ключи (защита от ghosting) */
            P1 = seg[digits[i]];   /* выставить код цифры на шину 1A-1H */
            P3 &= SEL[i];          /* открыть ключ i-го разряда */
            delay();               /* дать разряду посветиться */
        }
    }
}
