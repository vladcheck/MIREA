;====================================================================
; ПР №2, Задание 2 — контрольная сумма внешнего ПЗУ (ассемблер МК-51)
; Демо: Вар.7 — ПЗУ 8К (27C64), K=100, ZZZ=0800h, эталон 056h.
; Эталоны для других вариантов (сумма младших байтов адресов mod 256,
; содержимое ПЗУ стенда = младший байт адреса; вычислено скриптом):
;   Вар.8  (1000h,300): 032h
;   Вар.9  (2000h,500): 04Eh
;   Вар.10 (0C00h,150): 0A7h
;   Вар.11 (1000h,350): 093h
;   Вар.12 (0400h,650): 0EDh
; Чтение кода ПЗУ командой MOVC A,@A+DPTR (строб /PSEN).
; Совпадение -> P1.0=0, иначе P1.0=1 (LED).
; Счётчик K — 16-битный (R2:R3), т.к. K>255.
;====================================================================
$MOD51
ROM_ADDR EQU 0800h        ; ZZZ
ROM_SIZE EQU 100          ; K (Вар.7)
ROM_REF  EQU 056h         ; эталон из «резидентного ПЗУ»

        org 00h
        ljmp START
        org 30h
START:
        mov dptr,#ROM_ADDR ; DPTR := начало области
        mov r2,#00h         ; старший байт счётчика (100 = 00:64h)
        mov r3,#ROM_SIZE    ; младший байт счётчика
        mov r4,#00h         ; R4 := сумма (mod 256)
        clr a
LOOP:
        mov a,#00h          ; смещение 0 для MOVC
        movc a,@a+dptr      ; A := ROM[DPTR] (строб /PSEN, ALE фиксирует адрес)
        add a,r4            ; A := A + сумма
        mov r4,a            ; сохранить сумму
        inc dptr            ; следующий адрес
        ; R2:R3 := R2:R3 - 1 (16-битный декремент)
        mov a,r3
        dec r3
        cjne r3,#0FFh,NEXT  ; если младший не обернулся — дальше
        dec r2              ; иначе занять из старшего
NEXT:
        mov a,r2
        orl a,r3
        jnz LOOP            ; пока счётчик != 0
        ; сравнение с эталоном
        mov a,r4
        xrl a,#ROM_REF      ; 0 = совпало
        jz OK
        setb P1.0           ; mismatch -> LED on
        sjmp FAIL
OK:
        clr P1.0            ; match -> LED off
FAIL:
        sjmp FAIL           ; останов
        END
