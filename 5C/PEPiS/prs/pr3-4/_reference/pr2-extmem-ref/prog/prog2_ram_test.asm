;====================================================================
; ПР №2, Задание 1 — тестирование внешнего ОЗУ 1 Кбайт (ассемблер МК-51)
; Демо-вариант: Вар.1 — ОЗУ 8 Кбайт, паттерн XX=0AAh, старт ZZZ=0800h
; Для других вариантов (табл.8) заменить две строки EQU:
;   Вар.2: TEST_ADDR EQU 0100h / TEST_PAT EQU 055h   (ОЗУ 2К, HM6116)
;   Вар.3: TEST_ADDR EQU 0C00h / TEST_PAT EQU 000h   (ОЗУ 8К)
;   Вар.4: TEST_ADDR EQU 1000h / TEST_PAT EQU 0FFh   (ОЗУ 8К)
;   Вар.5: TEST_ADDR EQU 1400h / TEST_PAT EQU 055h   (ОЗУ 8К)
;   Вар.6: TEST_ADDR EQU 0400h / TEST_PAT EQU 0AAh   (ОЗУ 2К, HM6116)
; Схема: P0=AD0-AD7 (мультиплекс), U3 74LS373 фиксирует A0-A7 по спаду ALE,
;        P2=A8-A15, /WR=P3.6, /RD=P3.7, ошибка -> P1.0=1 (светодиод D1).
; Объём 1 Кбайт = 4 блока × 256 байт (двойной цикл: R2 внешний, R3 внутренний),
; т.к. один регистр считает максимум 255/256 (см. методичку: >255 байт — двойной цикл).
;====================================================================
$MOD51                    ; подключение регистров МК-51

TEST_ADDR EQU 0800h       ; ZZZ: начальный адрес тестовой области (Вар.1)
TEST_PAT  EQU 0AAh        ; XX: тестовый набор (Вар.1)
TEST_BLOCKS EQU 04h       ; 4 × 256 = 1024 байта = 1 Кбайт

        org 00h           ; вектор сброса
        ljmp START        ; переход на начало программы
        org 30h           ; тело программы после векторов прерываний
START:
        mov dptr,#TEST_ADDR ; DPTR := начальный адрес XRAM
        mov r1,#TEST_PAT    ; R1 := тестовый набор XX
        clr P1.0            ; LED погашен (ошибок пока нет)
        mov r2,#TEST_BLOCKS ; R2 := число блоков по 256 байт
OUTER:
        mov r3,#00h         ; R3 := 0; DJNZ даст 256 итераций (0->FF..->00)
INNER:
        mov a,r1            ; A := тестовый набор
        movx @dptr,a        ; запись A во внешнее ОЗУ (строб /WR, ALE фиксирует адрес)
        movx a,@dptr        ; чтение обратно (строб /RD)
        xrl a,#TEST_PAT     ; XOR с эталоном: 0 = совпало
        jnz ERROR           ; несовпадение -> ошибка, LED
        inc dptr            ; следующий адрес (DPTR+1)
        djnz r3,INNER       ; внутренний счётчик -1, пока не 0
        djnz r2,OUTER       ; внешний счётчик -1, пока не 0
        sjmp DONE           ; все 1024 ячейки исправны
ERROR:
        setb P1.0           ; зажечь светодиод ошибки
        sjmp ERROR          ; зависнуть с горящим LED (точка останова для отладчика)
DONE:
        sjmp DONE           ; успешное завершение (R2=0, DPTR=ZZZ+1024, P1.0=0)
        END
