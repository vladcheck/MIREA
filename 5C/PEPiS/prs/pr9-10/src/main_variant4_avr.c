/*====================================================================
 * Практическая работа № 5 «Отображение информации в
 * микроконтроллерных системах» (пр9-10, Proteus),
 * ИНДИВИДУАЛЬНЫЙ ВАРИАНТ 4 (табл. 9.26 методички) для ATmega32:
 * последовательная смена четырёх цифр по событию таймера.
 *
 * Параметры варианта 4:
 *   цифры        — 9-8-7-6;
 *   порядок      — обратный (индекс уменьшается, после нулевого
 *                  элемента принимает значение 3): на индикаторе
 *                  последовательность 9, 6, 7, 8, 9, 6, ...;
 *   T_симв       — 400 мс (интервал события таймера);
 *   диагностика  — применить инвертированный код.
 *
 * Таймер — Timer0 в режиме CTC по методике работы 9.3:
 * F_CPU = 8 МГц, предделитель 1024 -> отсчёт 128 мкс; OCR0 = 124,
 * то есть 125 отсчётов на совпадение -> событие каждые 16,000 мс;
 * 25 событий дают T_симв = 400,0 мс. Программная задержка в пустом
 * цикле не применяется: обработчик TIMER0_COMP устанавливает флаг
 * display_event, а основной цикл выводит следующий элемент массива.
 *
 * Порядок проверки по методике: сначала выводятся цифры 0, 8 и
 * одна цифра варианта (9) — каждая в течение одного интервала
 * T_симв (стартовая самопроверка), затем начинается цикл варианта.
 *
 * Сборка: GCC for AVR (avr-libc); HEX-файл загружается в модель
 * ATmega32 (частота модели 8 МГц) в Proteus 8.17.
 *====================================================================*/
#define F_CPU 8000000UL
#include <avr/interrupt.h>
#include <avr/io.h>
#include <stdint.h>

/* Диагностическое изменение варианта 4: «применить инвертированный
 * код». 0 — нормальный режим (индикатор общего катода, прямые коды);
 * 1 — код цифры инвертируется в пределах восьми младших битов, как
 * для индикатора с общим анодом. При неизменной схеме (общий катод)
 * изображение становится инверсным и нечитаемым. После наблюдения
 * вернуть 0 и пересобрать — параметры восстановятся. */
#define DISPLAY_INVERTED_CODE 0

/* T_симв = 400 мс = 25 событий по 16,000 мс:
 * предделитель 1024 -> 128 мкс на отсчёт, OCR0 = 124 -> 125
 * отсчётов на событие совпадения (16,000 мс). */
#define TIMER0_OCR_VALUE   124U
#define EVENTS_PER_SYMBOL  25U

/* Индивидуальный вариант 4: цифры 9-8-7-6, порядок обратный. */
static const uint8_t sequence[4] = {9U, 8U, 7U, 6U};
static volatile uint8_t display_event; /* флаг задаёт обработчик Timer0 */

/* Таблица кодов цифр для индикатора с ОБЩИМ КАТОДОМ:
 * младший бит — сегмент a, бит 6 — сегмент g, бит 7 — dp. */
static const uint8_t segment_code_cc[10] = {
    0x3FU, 0x06U, 0x5BU, 0x4FU, 0x66U,
    0x6DU, 0x7DU, 0x07U, 0x7FU, 0x6FU
};

static void Display_Digit(uint8_t digit)
{
    uint8_t code = 0U;

    if (digit < 10U) {
        code = segment_code_cc[digit];
    }

#if DISPLAY_INVERTED_CODE
    /* Диагностика варианта 4: инвертированный код. Для индикатора
     * с общим катодом вместо цифры отображается инверсный рисунок
     * (светятся сегменты, которые должны быть погашены). */
    code = (uint8_t)(~code);
#endif

    PORTA = code;
}

/* Timer0, CTC: OCR0 = 124, предделитель 1024 -> событие 16,000 мс. */
static void Timer0_DisplayEventInit(void)
{
    TCCR0 = 0U;
    TCNT0 = 0U;
    OCR0 = TIMER0_OCR_VALUE;
    TIFR = (1U << OCF0);   /* сброс флага совпадения (запись 1) */
    TIMSK |= (1U << OCIE0);/* прерывание по совпадению */
    sei();
    /* предделитель 1024 (CS02 = 1, CS01 = 0, CS00 = 1) + CTC (WGM01) */
    TCCR0 = (1U << WGM01) | (1U << CS02) | (1U << CS00);
}

ISR(TIMER0_COMP_vect)
{
    static uint8_t tick_count;

    tick_count++;
    if (tick_count >= EVENTS_PER_SYMBOL) {
        tick_count = 0U;
        display_event = 1U;
    }
}

int main(void)
{
    uint8_t index = 0U;
    /* Стартовая самопроверка по методике: цифры 0, 8 и цифра
     * варианта 9 — каждая в течение одного интервала T_симв. */
    static const uint8_t selftest[3] = {0U, 8U, 9U};
    uint8_t stage = 0U;

    DDRA = 0xFFU;  /* PA0–PA7 — выходы */
    PORTA = 0x00U; /* начальное состояние — все сегменты погашены */

    Timer0_DisplayEventInit();

    while (1) {
        if (display_event != 0U) {
            display_event = 0U;

            if (stage < 3U) {
                Display_Digit(selftest[stage]);
                stage++;
            } else {
                /* Обратный порядок: индекс уменьшается, после
                 * нулевого элемента принимает значение 3. */
                Display_Digit(sequence[index]);
                if (index == 0U) {
                    index = 3U;
                } else {
                    index--;
                }
            }
        }
    }
}
